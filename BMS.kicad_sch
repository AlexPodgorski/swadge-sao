File: BMS.kicad_sch (KiCad schematic)
At the start: 10 parts, among them U1 BQ24259

Commit message: Graphical Cleanup
Just visuals
Other:
- moved on the sheet: C11, C12, C2, C7
